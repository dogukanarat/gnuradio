options:
  parameters:
    id: train_rot
    title: Sine plus noise
    generate_options: qt_gui
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: F
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: Gain2
  id: blocks_multiply_const_vxx
  parameters:
    const: mu*g*M1
    type: float
  states: {}
- name: Sum1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: Gain
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/M1
    type: float
  states: {}
- name: Integrator
  id: blocks_integrate_xx
  parameters:
    decim: '1'
    type: float
  states: {}
- name: Integrator1
  id: blocks_integrate_xx
  parameters:
    decim: '1'
    type: float
  states: {}
- name: x1
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: '''x1'''
    size: '1024'
    srate: samp_rate
  states: {}
- name: x1_dot
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: '''x1_dot'''
    size: '1024'
    srate: samp_rate
  states: {}
- name: Sum2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: Gain1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/M2
    type: float
  states: {}
- name: Integrator2
  id: blocks_integrate_xx
  parameters:
    decim: '1'
    type: float
  states: {}
- name: Integrator3
  id: blocks_integrate_xx
  parameters:
    decim: '1'
    type: float
  states: {}
- name: x2
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: '''x2'''
    size: '1024'
    srate: samp_rate
  states: {}
- name: Gain4
  id: blocks_multiply_const_vxx
  parameters:
    const: mu*g*M2
    type: float
  states: {}
- name: Subtract
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: Gain3
  id: blocks_multiply_const_vxx
  parameters:
    const: k
    type: float
  states: {}

connections:
- [F, '0', Sum1, '0']
- [Gain2, '0', Sum1, '1']
- [Gain3, '0', Sum1, '2']
- [Sum1, '0', Gain, '0']
- [Gain, '0', Integrator, '0']
- [Integrator, '0', Integrator1, '0']
- [Integrator1, '0', x1, '0']
- [Integrator, '0', x1_dot, '0']
- [Integrator, '0', Gain2, '0']
- [Integrator1, '0', Subtract, '0']
- [Gain3, '0', Sum2, '0']
- [Gain4, '0', Sum2, '1']
- [Sum2, '0', Gain1, '0']
- [Gain1, '0', Integrator2, '0']
- [Integrator2, '0', Integrator3, '0']
- [Integrator3, '0', x2, '0']
- [Integrator2, '0', Gain4, '0']
- [Integrator3, '0', Subtract, '1']
- [Subtract, '0', Gain3, '0']

metadata:
  file_format: 1
  grc_version: '3.10'
